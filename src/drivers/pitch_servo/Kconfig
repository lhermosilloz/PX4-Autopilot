## src/drivers/pitch_servo/Kconfig
```kconfig
menuconfig DRIVERS_PITCH_SERVO
    bool "pitch_servo"
    default y
    ---help---
        Enable support for pitch servo gimbal stabilizer
```
